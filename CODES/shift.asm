MVI A,00H
STA 2000H
BEG:
LXI B,BBBBH
MOV D,A
LO:
DCX B
MOV A,B
ORA C
JNZ LO
MOV A,D
INR A
STA 2000H
CPI 0FH
JNZ BEG
MVI A,07H
STA 2000H
START:
LXI B,BBBBH
MOV D,A
LOOP:
DCX B
MOV A,B
ORA C
JNZ LOOP
MOV A,D
RLC
STA 2000H
JMP START
